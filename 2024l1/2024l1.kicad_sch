File: 2024l1/2024l1.kicad_sch (KiCad schematic)
At the start: 95 parts, among them J1 Conn_01x04, J2 Conn_01x04, SW1 SW_Push, SW2 SW_SPDT, U1 CD74HC4067SM, U2 CD74HC4067SM, U3 STM32F103CBTx, Y1 8Mhz

Commit message: l1 - started routing
Connections:
- net M1_S0: no longer U3.42 (PB6)
- net M1_S1: no longer U3.43 (PB7)
- net M1_S2: no longer U3.41 (PB5)
- net M1_S3: no longer U3.40 (PB4)
- net M2: no longer U3.19 (PB1)
- net M2_S0: no longer U3.20 (PB2)
- net M2_S1: no longer U3.21 (PB10)
- net M2_S2: no longer U3.18 (PB0)
- net M2_S3: no longer U3.16 (PA6), U3.17 (PA7)
Changed lines of the file:
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@@
   (no_connect (at 320.04 121.92))
   (no_connect (at 320.04 111.76))
-  (wire (pts (xy 353.06 71.12) (xy 360.68 71.12))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 294.64 71.12) (xy 309.88 71.12))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 312.42 101.6) (xy 320.04 101.6))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 106.68 184.15) (xy 116.84 184.15))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 314.96 86.36) (xy 320.04 86.36))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 223.52 45.72) (xy 223.52 48.26))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 312.42 93.98) (xy 320.04 93.98))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 96.52 184.15) (xy 106.68 184.15))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 312.42 109.22) (xy 320.04 109.22))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 83.82 217.17) (xy 83.82 222.25))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 312.42 96.52) (xy 320.04 96.52))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 76.2 161.29) (xy 76.2 158.75))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 353.06 73.66) (xy 360.68 73.66))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 335.28 50.8) (xy 335.28 48.26))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 312.42 88.9) (xy 320.04 88.9))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 78.74 245.11) (xy 78.74 247.65))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 312.42 99.06) (xy 320.04 99.06))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 83.82 214.63) (xy 83.82 209.55))
     (stroke (width 0) (type default))
@@
   )
   (wire (pts (xy 116.84 172.72) (xy 106.68 172.72))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 312.42 83.82) (xy 320.04 83.82))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "M2_S2" (at 314.96 83.82 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "M2" (at 317.5 86.36 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "M1_S0" (at 314.96 99.06 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (label "M1_S1" (at 116.84 88.9 270) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "M1_S2" (at 314.96 96.52 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "M2_S3" (at 360.68 73.66 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right bottom))
-  )
   (label "BOOT" (at 314.96 60.96 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
   (label "SWDIO" (at 386.08 111.76 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "M2_S0" (at 314.96 88.9 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
-  (label "M2_S3" (at 360.68 71.12 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right bottom))
-  )
   (label "M2_S2" (at 208.28 88.9 270) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "M2_S1" (at 314.96 109.22 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "M1_S1" (at 314.96 101.6 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (label "M2_S1" (at 205.74 88.9 270) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
-  (label "M1_S3" (at 314.96 93.98 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (label "RX" (at 358.14 63.5 180) (fields_autoplaced)

Commit message: l1 - finish stm to mux
Connections:
- net M1: now also U3.41 (PB5)
- net M1_S0: now also U3.42 (PB6)
- net M1_S1: now also U3.43 (PB7)
- net M1_S2: now also U3.40 (PB4)
- net M1_S3: now also U3.39 (PB3)
- net M2: now also U3.18 (PB0)
- net M2_S0: now also U3.19 (PB1)
- net M2_S1: now also U3.20 (PB2)
- net M2_S2: now also U3.17 (PA7)
- net M2_S3: now also U3.16 (PA6)
- no-connect marks 23 -> 22
Changed lines of the file:
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@@
   (no_connect (at 353.06 68.58))
   (no_connect (at 320.04 78.74))
-  (no_connect (at 320.04 91.44))
   (no_connect (at 320.04 76.2))
   (no_connect (at 353.06 81.28))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 320.04 83.82) (xy 312.42 83.82))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 86.36 142.24) (xy 96.52 142.24))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 320.04 96.52) (xy 312.42 96.52))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 99.06 55.88) (xy 99.06 60.96))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 312.42 91.44) (xy 320.04 91.44))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 96.52 184.15) (xy 106.68 184.15))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 353.06 73.66) (xy 360.68 73.66))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 127 45.72) (xy 127 48.26))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 320.04 101.6) (xy 312.42 101.6))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 106.68 172.72) (xy 96.52 172.72))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 320.04 93.98) (xy 312.42 93.98))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 76.2 172.72) (xy 76.2 173.99))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 353.06 71.12) (xy 360.68 71.12))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 137.16 133.35) (xy 137.16 130.81))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 320.04 88.9) (xy 312.42 88.9))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 116.84 140.97) (xy 116.84 142.24))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 312.42 86.36) (xy 320.04 86.36))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 279.4 66.04) (xy 281.94 66.04))
     (stroke (width 0) (type default))
@@
   )
   (wire (pts (xy 314.96 68.58) (xy 314.96 71.12))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 312.42 99.06) (xy 320.04 99.06))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
+  (label "M1_S2" (at 313.055 93.98 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "M1_S1" (at 116.84 88.9 270) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
+  (label "M2_S0" (at 313.055 86.36 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (label "M1_S1" (at 313.055 101.6 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "SWCLK" (at 355.6 91.44 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (label "M1_S3" (at 313.055 91.44 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
+  (label "M1" (at 313.055 96.52 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "LED" (at 314.96 73.66 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
+  (label "M2_S2" (at 360.045 73.66 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
   (label "GND" (at 91.44 206.375 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
+  (label "M2_S3" (at 360.045 71.12 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
+  (label "M2" (at 313.055 83.82 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (label "M1_S0" (at 313.055 99.06 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (label "M2_S1" (at 313.055 88.9 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "RX" (at 358.14 63.5 180) (fields_autoplaced)

Commit message: l1 - Moved MUX Wiring
Parts:
- removed J?: XT30, 2024l1:AMASS_XT30-F, symbol Connector_Generic:Conn_01x02
- added J5: Conn_01x04, Connector_JST:JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical, symbol Connector_Generic:Conn_01x04
- added KM1, KM2: MountingHole_Pad, symbol Mechanical:MountingHole_Pad
Connections:
- net +12V: now also J5.1 (Pin_1), J5.2 (Pin_2)
- net GND: now also J5.3 (Pin_3), J5.4 (Pin_4)
- net M2: now also U3.20 (PB2); no longer U3.18 (PB0)
- net M2_S0: now also U3.21 (PB10); no longer U3.19 (PB1)
- net M2_S1: now also U3.22 (PB11); no longer U3.20 (PB2)
- net M2_S2: now also U3.19 (PB1); no longer U3.17 (PA7)
- net M2_S3: now also U3.18 (PB0); no longer U3.16 (PA6)
- no-connect marks 22 -> 23
