File: 2024l1/2024l1.kicad_sch (KiCad schematic)
At the start: 97 parts, among them J1 Conn_01x04, J2 Conn_01x04, J5 Conn_01x04, SW1 SW_Push, SW2 SW_SPDT, U1 CD74HC4067SM, U2 CD74HC4067SM, U3 STM32F103CBTx, Y1 8Mhz

Commit message: L1-Added Logo, Routing,Mounting Hole, LG(Incomplete)
Parts:
- added D33: LED, Connector_PinSocket_2.54mm:PinSocket_1x02_P2.54mm_Vertical, symbol Device:LED
- added H1: MountingHole, symbol Mechanical:MountingHole
- added R42: R_Photo, Connector_PinSocket_2.54mm:PinSocket_1x02_P2.54mm_Vertical, symbol Device:R_Photo
- added R43: 1k, 2024l1:res0603, symbol Device:R
Connections:
- net +3V3: now also D33.2 (A), R42.1
- net GND: now also D33.1 (K), R43.2
- net LG: now reaches U3.30 (PA9)
- net LG: now also R42.2, R43.1
- no-connect marks 23 -> 22
Changed lines of the file:
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@@
   (junction (at 116.84 156.21) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 383.54 61.468) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 78.74 222.25) (diameter 0) (color 0 0 0 0)
   )
@@
   (no_connect (at 353.06 55.88))
   (no_connect (at 353.06 66.04))
-  (no_connect (at 353.06 78.74))
   (no_connect (at 226.06 60.96))
   (no_connect (at 320.04 106.68))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 353.06 78.74) (xy 358.14 78.74))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 127 146.05) (xy 137.16 146.05))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 375.92 61.468) (xy 383.54 61.468))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 101.6 45.72) (xy 99.06 45.72))
     (stroke (width 0) (type default))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
+  (label "LG" (at 358.14 78.74 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
   (label "M1_S1" (at 116.84 88.9 270) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
+  (label "LG" (at 375.92 61.468 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "M1_S0" (at 313.055 99.06 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     )
   )
+  (symbol (lib_id "power:+3V3") (at 383.54 53.848 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR034" (at 383.54 57.658 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+3V3" (at 383.54 50.292 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 383.54 53.848 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 383.54 53.848 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "2024l1"
+        (path "/5be543b5-1bdc-438f-a916-f916127c0a2b"
+          (reference "#PWR034") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 125.095 212.09 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "power:GND") (at 383.54 69.088 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR035" (at 383.54 75.438 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 383.54 73.914 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 383.54 69.088 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 383.54 69.088 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "2024l1"
+        (path "/5be543b5-1bdc-438f-a916-f916127c0a2b"
+          (reference "#PWR035") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "vincent:C") (at 172.72 85.09 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "power:GND") (at 398.272 61.722 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR039" (at 398.272 68.072 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 398.272 67.31 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 398.272 61.722 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 398.272 61.722 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "2024l1"
+        (path "/5be543b5-1bdc-438f-a916-f916127c0a2b"
+          (reference "#PWR039") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:R_Photo") (at 198.12 52.07 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "power:+3V3") (at 398.272 54.102 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR037" (at 398.272 57.912 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+3V3" (at 398.272 50.8 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 398.272 54.102 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 398.272 54.102 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "2024l1"
+        (path "/5be543b5-1bdc-438f-a916-f916127c0a2b"
+          (reference "#PWR037") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:R_Photo") (at 111.76 52.07 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "Mechanical:MountingHole") (at 172.72 220.218 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "H1" (at 175.26 219.583 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (at 175.26 222.123 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (at 172.72 220.218 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 172.72 220.218 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (instances
+      (project "2024l1"
+        (path "/5be543b5-1bdc-438f-a916-f916127c0a2b"
+          (reference "H1") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:LED") (at 308.61 73.66 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
     )
   )
+  (symbol (lib_id "Device:R") (at 383.54 65.278 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "R43" (at 386.08 64.643 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "1k" (at 386.08 67.183 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "2024l1:res0603" (at 381.762 65.278 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 383.54 65.278 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "2024l1"
+        (path "/5be543b5-1bdc-438f-a916-f916127c0a2b"
+          (reference "R43") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 182.88 132.08 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "Device:LED") (at 398.272 57.912 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "D33" (at 401.32 58.8645 90)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "LED" (at 401.32 61.4045 90)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "Connector_PinSocket_2.54mm:PinSocket_1x02_P2.54mm_Vertical" (at 398.272 57.912 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 398.272 57.912 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "2024l1"
+        (path "/5be543b5-1bdc-438f-a916-f916127c0a2b"
+          (reference "D33") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 383.54 116.84 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "Device:R_Photo") (at 383.54 57.658 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "R42" (at 386.08 57.023 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "R_Photo" (at 386.08 59.563 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Connector_PinSocket_2.54mm:PinSocket_1x02_P2.54mm_Vertical" (at 384.81 64.008 90)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+    (property "Datasheet" "~" (at 383.54 58.928 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "2024l1"
+        (path "/5be543b5-1bdc-438f-a916-f916127c0a2b"
+          (reference "R42") (unit 1)
+        )
+      )

Commit message: l1 - MTH & silkscrn
Parts:
- removed H1: MountingHole, symbol Mechanical:MountingHole
- added MTH1, MTH10, MTH11, MTH12, MTH13, MTH14, MTH15, MTH16, MTH2, MTH3, MTH4, MTH5, MTH6, MTH7, MTH8, MTH9: MountingHole_Pad, MountingHole:MountingHole_3.2mm_M3_Pad_Via, symbol Mechanical:MountingHole_Pad
- KM1, KM2: footprint (none) -> MountingHole:MountingHole_4.3mm_M4_Pad_Via

Commit message: l1 - MTH Desginators
Connections:
- net RX: now also J1.2 (Pin_2); no longer J1.3 (Pin_3)
- net TX: now also J1.3 (Pin_3); no longer J1.2 (Pin_2)
Changed lines of the file:
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@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "RX" (at 175.26 129.54 0) (fields_autoplaced)
+  (label "RX" (at 175.26 127 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
-  (label "TX" (at 175.26 127 0) (fields_autoplaced)
+  (label "TX" (at 175.26 129.54 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )

Commit message: l1 - PGMR 3V3
Parts:
- removed SW2: SW_SPDT, 2024l1:SS12D00G3, symbol Switch:SW_SPDT
- renumbered J5 to J4
Connections:
- net PGMR_3V3 is gone; now on net +3V3: J2.1 (Pin_1)
- no-connect marks 22 -> 21
Changed lines of the file:
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@@
   (no_connect (at 353.06 83.82))
   (no_connect (at 320.04 114.3))
-  (no_connect (at 368.3 111.76))
   (no_connect (at 137.16 60.96))
   (no_connect (at 320.04 104.14))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 378.46 109.22) (xy 391.16 109.22))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 119.38 45.72) (xy 116.84 45.72))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 365.76 106.68) (xy 368.3 106.68))
+  (wire (pts (xy 383.54 109.22) (xy 391.16 109.22))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "PGMR_3V3" (at 381 109.22 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (label "BOOT" (at 314.96 60.96 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     )
   )
-  (symbol (lib_id "power:+3V3") (at 365.76 106.68 90) (unit 1)
+  (symbol (lib_id "power:+3V3") (at 383.54 109.22 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR026" (at 369.57 106.68 0)
+    (property "Reference" "#PWR026" (at 387.35 109.22 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Value" "+3V3" (at 361.95 106.6799 90)
+    (property "Value" "+3V3" (at 379.73 109.2199 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (at 365.76 106.68 0)
+    (property "Footprint" "" (at 383.54 109.22 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 365.76 106.68 0)
+    (property "Datasheet" "" (at 383.54 109.22 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Connector_Generic:Conn_01x04") (at 136.525 207.01 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "J5" (at 136.525 198.12 0)
+    (property "Reference" "J4" (at 136.525 198.12 0)
       (effects (font (size 1.27 1.27)))
     )
@@
       (project "2024l1"
         (path "/5be543b5-1bdc-438f-a916-f916127c0a2b"
-          (reference "J5") (unit 1)
+          (reference "J4") (unit 1)
         )
       )
@@
         )
       )
-    )
-  )
-  (symbol (lib_id "Switch:SW_SPDT") (at 373.38 109.22 0) (mirror y) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "SW2" (at 373.38 101.6 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "SW_SPDT" (at 373.38 104.14 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "2024l1:SS12D00G3" (at 373.38 109.22 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 373.38 109.22 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (pin "3")
-    (instances
-      (project "2024l1"
-        (path "/5be543b5-1bdc-438f-a916-f916127c0a2b"
-          (reference "SW2") (unit 1)
-        )
-      )
