# Repository senrobo/elec-24

File README.md:

## Sentinels 2024 Electrical Repository
### Folder Structure
```bash
├── 2024l1
│  ├── 3dmodels
│  ├── 2024l1-backups
│  ├── 2024l1.kicad_pcb
│  ├── 2024l1.kicad_prl
│  ├── 2024l1.kicad_pro
│  ├── 2024l1.kicad_sch
│  ├── 2024l1.pretty
│  ├── fp-info-cache
│  └── fp-lib-table
├── 2024l2
│  ├── 3dmodels
│  ├── 2024l2-backups
│  ├── 2024l2.kicad_pcb
│  ├── 2024l2.kicad_prl
│  ├── 2024l2.kicad_pro
│  ├── 2024l2.kicad_sch
│  ├── 2024l2.pretty
│  ├── 2024l2.step
│  ├── bom
│  │  └── ibom.html
│  ├── fp-info-cache
│  └── fp-lib-table
├── 2024l3
│  ├── 3dmodels
│  ├── 2024l3-backups
│  ├── 2024l3.kicad_pcb
│  ├── 2024l3.kicad_prl
│  ├── 2024l3.kicad_pro
│  ├── 2024l3.kicad_sch
│  ├── 2024l3.pretty
│  ├── fp-info-cache
│  └── fp-lib-table
├── Extras
│  ├── 2024l2 (VNH5019)
│  │  ├── 3dmodels
│  │  ├── 2024l2 (VNH5019).kicad_pcb
│  │  ├── 2024l2 (VNH5019).kicad_pro
│  │  ├── 2024l2 (VNH5019).kicad_sch
│  │  ├── 2024l2.pretty
│  │  ├── bom
│  │  │  └── ibom.html
│  │  └── fp-lib-table
│  ├── Castellated Boards
│  │  ├── Camera Castellated Board
│  │  │  ├── 2024l3.pretty
│  │  │  ├── Camera Castellated Board-backups
│  │  │  ├── Camera Castellated Board.kicad_pcb
│  │  │  ├── Camera Castellated Board.kicad_pro
│  │  │  └── Camera Castellated Board.kicad_sch
│  │  ├── Compass Castellated Board
│  │  │  ├── 2024l3.pretty
│  │  │  ├── Compass Castellated Board.kicad_pcb
│  │  │  ├── Compass Castellated Board.kicad_pro
│  │  │  └── Compass Castellated Board.kicad_sch
│  │  ├── Screen Castellated Board
│  │  │  ├── 2024l3.pretty
│  │  │  ├── Screen Castellated Board.kicad_pcb
│  │  │  ├── Screen Castellated Board.kicad_pro
│  │  │  └── Screen Castellated Board.kicad_sch
│  │  ├── Teensy Castellated Board
│  │  │  ├── Teensy Castellated Board.kicad_pcb
│  │  │  ├── Teensy Castellated Board.kicad_pro
│  │  │  ├── Teensy Castellated Board.kicad_sch
│  │  │  └── Teensy Castellated Board.step
│  │  └── XIAO Castellated Board
│  │     ├── 2024l1.pretty
│  │     ├── XIAO Castellated Board.kicad_pcb
│  │     ├── XIAO Castellated Board.kicad_pro
│  │     └── XIAO Castellated Board.kicad_sch
│  ├── test (Hardware)
│  │  ├── 3dmodels
│  │  ├── fp-lib-table
│  │  ├── test(Hardware).kicad_pcb
│  │  ├── test(Hardware).kicad_pro
│  │  ├── test(Hardware).kicad_sch
│  │  └── test.pretty
│  └── test (SPI)
│     ├── 3dmodels
│     ├── fp-lib-table
│     ├── test.kicad_pcb
│     ├── test.kicad_pro
│     ├── test.kicad_sch
│     └── test.pretty
├── LG Plates
│  ├── LDR Plate
│  │  ├── LDR Plate.kicad_pcb
│  │  ├── LDR Plate.kicad_pro
│  │  └── LDR Plate.kicad_sch
│  └── LED Plate
│     ├── LED Plate.kicad_pcb
│     ├── LED Plate.kicad_pro
│     └── LED Plate.kicad_sch
├── LICENSE
└── README.md
```
Feel free to copy our designs but don't forget to give us some love by giving us credit ❤️

## KiCad design 2024l1/2024l1.kicad_pcb

Parts:
C1, C2: 0.1u; cap0603; LCSC C5463924
C4: 1500pF; cap0603; LCSC C107060
C5, C6, C7, C8, C9: 1000uF; CP_Radial_D16.0mm_P7.50mm; LCSC C1669545
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: LED; led2835; LCSC C7423447
D37: 1N5401; D_DO-201AD_P15.24mm_Horizontal; LCSC C179506
J1: LED; PinSocket_1x02_P2.54mm_Vertical
J4: LDR; PinSocket_1x02_P2.54mm_Vertical
J5: XT30; AMASS_XT30-F; LCSC C108769
KM1, KM2: M4; MountingHole_4.3mm_M4_Pad_Via
LOGO1: Infineon Smaller
LOGO2: SEN Logo Mini
MTH1, MTH2, MTH3, MTH4, MTH5, MTH6, MTH7, MTH8, MTH9, MTH10, MTH11, MTH12, MTH13, MTH14, MTH15, MTH16, MTH17, MTH18: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
Q1: STP75NF75; TO-220-3_Vertical; Mouser Part Number 726-IPD050N10N5ATMA1; LCSC C13678
Q2: IRLML6344TRPBF; SOT95P237X112-3N; Mouser Part Number 942-IRLML6344TRPBF
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30: C146233; ALS-PT19 (Top Side); LCSC C146233
R48, R50: 3K24; res0603; LCSC C22994
R49, R51, R56: 10K; res0603; LCSC C25804
R54: 20R; res0603; LCSC C22950
R55, R57: 1K; res0603; LCSC C21190
R58: 20k; res2512
R84: 10k; res0603
SW2: SW_SPDT; SS12D00G3
TP1: GND; 14 AWG
TP2: 48V; 14 AWG
TP3: 3v3; 14 AWG
U1, U2: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm

Connections:
+3V3: C1.1, C2.1, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A), J4.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R84.2, TP3.1, U1.24 (VCC), U2.24 (VCC)
+12V: R55.1, R56.1
+48V: C5.1, C6.1, C7.1, C8.1, C9.1, D37.1 (K), J5.2, R58.1, TP2.1
/LG: J4.1, U2.16 (I15)
/M1: R48.2, U1.1 (COM)
/M2: R50.2, U2.1 (COM)
/S0: U1.10 (S0), U2.10 (S0)
/S1: U1.11 (S1), U2.11 (S1)
/S2: U1.14 (S2), U2.14 (S2)
/S3: U1.13 (S3), U2.13 (S3)
/Sol: Q2.1 (G), R57.1
GND: C1.2, C2.2, C5.2, C6.2, C7.2, C8.2, C9.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), J1.2, Q2.2 (S), R48.1, R49.1, R50.1, R51.1, R57.2, SW2.2 (B), TP1.1, U1.12 (GND), U2.12 (GND)
unnamed: C4.1, R54.2
unnamed: D37.2 (A), J5.1, Q1.2 (D), R54.1
unnamed: J1.1, R84.1
unnamed: Q1.1 (G), R55.2
unnamed: C4.2, Q1.3 (S), Q2.3 (D), R56.2
unnamed: R58.2, SW2.3 (C)
unnamed: R1.2, U1.9 (I0)
unnamed: R2.2, U1.8 (I1)
unnamed: R3.2, U1.7 (I2)
unnamed: R4.2, U1.6 (I3)
unnamed: R5.2, U1.5 (I4)
unnamed: R6.2, U1.4 (I5)
unnamed: R7.2, U1.3 (I6)
unnamed: R8.2, U1.2 (I7)
unnamed: R9.2, U1.23 (I8)
unnamed: R10.2, U1.22 (I9)
unnamed: R11.2, U1.21 (I10)
unnamed: R12.2, U1.20 (I11)
unnamed: R13.2, U1.19 (I12)
unnamed: R14.2, U1.18 (I13)
unnamed: R15.2, U1.17 (I14)
unnamed: R49.2, U1.15 (~E)
unnamed: R16.2, U2.9 (I0)
unnamed: R17.2, U2.8 (I1)
unnamed: R18.2, U2.7 (I2)
unnamed: R19.2, U2.6 (I3)
unnamed: R20.2, U2.5 (I4)
unnamed: R21.2, U2.4 (I5)
unnamed: R22.2, U2.3 (I6)
unnamed: R23.2, U2.2 (I7)
unnamed: R24.2, U2.23 (I8)
unnamed: R25.2, U2.22 (I9)
unnamed: R26.2, U2.21 (I10)
unnamed: R27.2, U2.20 (I11)
unnamed: R28.2, U2.19 (I12)
unnamed: R29.2, U2.18 (I13)
unnamed: R30.2, U2.17 (I14)
unnamed: R51.2, U2.15 (~E)

Notes on the sheet:
MUX
MTH and Testpoints
LED
Activation Circuit

Board: 2 copper layers, 174.0 x 165.6 mm, 112 parts (74 on the bottom side), 50 nets.

## KiCad design 2025l1/2025l1.kicad_pcb

Board: 2 copper layers, 176.0 x 170.0 mm, 86 parts (62 on the bottom side), 44 nets.

Parts:
C4, C5: 10u; cap0603
C8, C9: 10n; cap0603
C10, C11: 220u; EIA-7343-D
C13, C14: 0u1; cap0603
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: LED; led0603
D31, D32: SS54; SMA (DO-214AC)
J5: Conn_01x02; AMASS_XT30-F
L2, L3: 15uH; 0630 One Piece Inductor
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R31: C146233; ALS-PT19 (Top Side)
R38, R40: 10K; res0603
R39: 5K9; res0603
R41: 3K24; res0603
TP6: 5V; 14 AWG
TP7: 48V; 14 AWG
TP8: 3v3; 14 AWG
TP9: GND; 14 AWG
TP10: 12V; 14 AWG
U1, U2: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm
U3, U4: TPS5430DDA; TI_SO-PowerPAD-8

Connections:
+3V3: C10.1, C13.1, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A), L2.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R31.1, R38.1, TP8.1, U1.24 (VCC), U2.24 (VCC)
+5V: C11.1, C14.1, L3.2, R40.1, TP6.1
+12V: C4.1, C5.1, J5.2, TP10.1, U3.7 (VIN), U4.7 (VIN)
/LED Ring/mux/S0: U1.10 (S0), U2.10 (S0)
/LED Ring/mux/S1: U1.11 (S1), U2.11 (S1)
/LED Ring/mux/S2: U1.14 (S2), U2.14 (S2)
/LED Ring/mux/S3: U1.13 (S3), U2.13 (S3)
GND: C4.2, C5.2, C10.2, C11.2, C13.2, C14.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.2 (A), D32.2 (A), J5.1, R39.2, R41.2, TP9.1, U1.12 (GND), U2.12 (GND), U3.6 (GND), U3.9 (GNDPAD), U4.6 (GND), U4.9 (GNDPAD)
unnamed: C8.2, D31.1 (K), L2.1, U3.8 (PH)
unnamed: C9.2, D32.1 (K), L3.1, U4.8 (PH)
unnamed: R16.2, U1.9 (I0)
unnamed: R17.2, U1.8 (I1)
unnamed: R18.2, U1.7 (I2)
unnamed: R19.2, U1.6 (I3)
unnamed: R20.2, U1.5 (I4)
unnamed: R21.2, U1.4 (I5)
unnamed: R22.2, U1.3 (I6)
unnamed: R23.2, U1.2 (I7)
unnamed: R24.2, U1.23 (I8)
unnamed: R25.2, U1.22 (I9)
unnamed: R26.2, U1.21 (I10)
unnamed: R27.2, U1.20 (I11)
unnamed: R28.2, U1.19 (I12)
unnamed: R29.2, U1.18 (I13)
unnamed: R31.2, U1.17 (I14)
unnamed: R1.2, U2.9 (I0)
unnamed: R2.2, U2.8 (I1)
unnamed: R3.2, U2.7 (I2)
unnamed: R4.2, U2.6 (I3)
unnamed: R5.2, U2.5 (I4)
unnamed: R6.2, U2.4 (I5)
unnamed: R7.2, U2.3 (I6)
unnamed: R8.2, U2.2 (I7)
unnamed: R9.2, U2.23 (I8)
unnamed: R10.2, U2.22 (I9)
unnamed: R11.2, U2.21 (I10)
unnamed: R12.2, U2.20 (I11)
unnamed: R13.2, U2.19 (I12)
unnamed: R14.2, U2.18 (I13)
unnamed: R15.2, U2.17 (I14)
unnamed: C8.1, U3.1 (BOOT)
unnamed: R38.2, R39.1, U3.4 (VSENSE)
unnamed: C9.1, U4.1 (BOOT)
unnamed: R40.2, R41.1, U4.4 (VSENSE)

## KiCad design 2024l2/2024l2.kicad_pcb

Board: 2 copper layers, 174.0 x 141.0 mm, 127 parts (55 on the bottom side), 70 nets.

Parts:
C1, C2: 10u; cap0603
C3, C4: 10n; cap0603
C5, C6: 220u; EIA-7343-D
C7, C8, C9, C12, C16, C18, C20, C22: 0u1; cap0603
C10: 100u; CP_Elec_8x6.5
C11: 1u; cap0603
C13: 220uF; CP_Elec_10x10.5
C15, C17, C19, C21: 470u; CP_Radial_D8.0mm_P3.50mm
D1, D2: SS54; SMA (DO-214AC)
D3: SS510; SMA (DO-214AC)
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
IC1: LM2587S-ADJ; TO170P1435X465-6N
IC2, IC3, IC4, IC5: VNH5019ATR-E; VNH5019A-E
J1, J15: Conn_01x01; 14 AWG
J2: Conn_01x02; AMASS_XT30-F
J3, J5: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J6: Conn_01x06; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J7, J8, J9, J10, J11, J12, J13, J14: Conn_01x01; 18 AWG
L1, L2: 15uH; 0630 One Piece Inductor
L3: 68uH; 1040 One Piece Inductor
LOGO1: Battery
Q1, Q2, Q3, Q4: AON6354; 8-DFN (5x6)
R1, R3, R15, R23, R38, R39: 10K; res0603
R2: 5K9; res0603
R4: 3K24; res0603
R5: 2k94; res0603
R6: 57K; res0603
R7: 1K5; res0603
R8, R9, R16, R17, R24, R25, R26, R27: 3K3; res0603
R10, R11, R12, R13, R14, R18, R19, R20, R21, R22, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37: 1K; res0603
SW1: SW_SPDT; SS12D00G3
SW2: SW_SPST; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
U1, U2: TPS5430DDA; TI_SO-PowerPAD-8
U3: Teensy 4.0
kibuzzard-65E7E5C9, kibuzzard-65E7E5C9#2: G***; kibuzzard-65E7E5C9
kibuzzard-655F61C6, kibuzzard-655F61C6#2, kibuzzard-655F61C6#3, kibuzzard-655F61C6#4: G***; kibuzzard-655F61C6
kibuzzard-655F623A, kibuzzard-655F623A#2: G***; kibuzzard-655F623A
kibuzzard-655F6265, kibuzzard-655F6265#2: G***; kibuzzard-655F6265
kibuzzard-658F8E40, kibuzzard-658F8E40#2: G***; kibuzzard-658F8E40
kibuzzard-658F913C, kibuzzard-658F913C#2: G***; kibuzzard-658F913C
kibuzzard-658F9141, kibuzzard-658F9141#2: G***; kibuzzard-658F9141
kibuzzard-6592C29D: G***; kibuzzard-6592C29D

Connections:
+3V3: C5.1, C7.1, J5.4, J6.2, L1.2, R1.1, R8.2, R9.2, R16.2, R17.2, R24.2, R25.2, R26.2, R27.2
+5V: C6.1, C8.1, J3.4, J6.1, L2.2, R3.1, SW1.1 (A)
+12V: C1.1, C2.1, C9.1, C10.1, IC1.5 (VIN), IC2.12 (VBAT), IC3.12 (VBAT), IC4.12 (VBAT), IC5.12 (VBAT), J1.1, J2.2, J5.3, L3.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), U1.7 (VIN), U2.7 (VIN)
+48V: C12.1, C13.1, D3.1 (K), J5.2, R6.1
/CPM1: IC2.11 (CP), Q1.4 (G)
/CPM2: IC3.11 (CP), Q2.4 (G)
/CPM3: IC4.11 (CP), Q3.4 (G)
/CPM4: IC5.11 (CP), Q4.4 (G)
/ESC: J4.1, U3.0 (0/RX1)
/L1 RX: J3.1, U3.15 (15/A1/RX3)
/L1 TX: J3.3, U3.14 (14/A0/TX3)
/L3 RX: J6.3, U3.21 (21/A7/RX5)
/L3 TX: J6.4, U3.20 (20/A6/TX5)
/M1 IN A: R12.1, U3.3
/M1 IN B: R13.1, U3.1 (1/TX1)
/M1 PWM: R14.1, R15.1, U3.2
/M2 IN A: R20.1, U3.6
/M2 IN B: R21.1, U3.4
/M2 PWM: R22.1, R23.1, U3.5
/M3 IN A: R32.1, U3.9
/M3 IN B: R34.1, U3.7 (7/RX2)
/M3 PWM: R36.1, R38.1, U3.8 (8/TX2)
/M4 IN A: R33.1, U3.12 (12/MISO)
/M4 IN B: R35.1, U3.10 (10/CS)
/M4 PWM: R37.1, R39.1, U3.11 (11/MOSI)
/M SW: R8.1, R9.1, R10.1, R11.1, R16.1, R17.1, R18.1, R19.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, SW2.1 (A)
/OUT A M1: IC2.1 (OUTA), IC2.25 (OUTA), IC2.30 (OUTA), IC2.31 (OUTA), J7.1
/OUT A M2: IC3.1 (OUTA), IC3.25 (OUTA), IC3.30 (OUTA), IC3.31 (OUTA), J9.1
/OUT A M3: IC4.1 (OUTA), IC4.25 (OUTA), IC4.30 (OUTA), IC4.31 (OUTA), J11.1
/OUT A M4: IC5.1 (OUTA), IC5.25 (OUTA), IC5.30 (OUTA), IC5.31 (OUTA), J13.1
/OUT B M1: IC2.15 (OUTB), IC2.16 (OUTB), IC2.21 (OUTB), IC2.32 (OUTB), J8.1
/OUT B M2: IC3.15 (OUTB), IC3.16 (OUTB), IC3.21 (OUTB), IC3.32 (OUTB), J10.1
/OUT B M3: IC4.15 (OUTB), IC4.16 (OUTB), IC4.21 (OUTB), IC4.32 (OUTB), J12.1
/OUT B M4: IC5.15 (OUTB), IC5.16 (OUTB), IC5.21 (OUTB), IC5.32 (OUTB), J14.1
/TEENSY PWR: SW1.2 (B), U3.VIN
GND: C1.2, C2.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, D1.2 (A), D2.2 (A), IC1.3 (GND), IC1.6 (TAB), IC2.18 (GND), IC2.19 (GND), IC2.20 (GND), IC2.26 (GND), IC2.27 (GND), IC2.28 (GND), IC3.18 (GND), IC3.19 (GND), IC3.20 (GND), IC3.26 (GND), IC3.27 (GND), IC3.28 (GND), IC4.18 (GND), IC4.19 (GND), IC4.20 (GND), IC4.26 (GND), IC4.27 (GND), IC4.28 (GND), IC5.18 (GND), IC5.19 (GND), IC5.20 (GND), IC5.26 (GND), IC5.27 (GND), IC5.28 (GND), J2.1, J3.2, J4.3, J5.1, J6.5, J6.6, J15.1, R2.2, R4.2, R7.2, R15.2, R23.2, R38.2, R39.2, SW2.2 (B), U1.6 (GND), U1.9 (GNDPAD), U2.6 (GND), U2.9 (GNDPAD), U3.G1, U3.G3
unnamed: C11.1, R5.2
unnamed: C15.1, C16.1, IC2.3 (VCC), IC2.13 (VCC), IC2.23 (VCC), IC2.33 (VCC), Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q1.9 (D)
unnamed: C17.1, C18.1, IC3.3 (VCC), IC3.13 (VCC), IC3.23 (VCC), IC3.33 (VCC), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.9 (D)
unnamed: C19.1, C20.1, IC4.3 (VCC), IC4.13 (VCC), IC4.23 (VCC), IC4.33 (VCC), Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), Q3.9 (D)
unnamed: C21.1, C22.1, IC5.3 (VCC), IC5.13 (VCC), IC5.23 (VCC), IC5.33 (VCC), Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), Q4.9 (D)
unnamed: C3.2, D1.1 (K), L1.1, U1.8 (PH)
unnamed: C4.2, D2.1 (K), L2.1, U2.8 (PH)
unnamed: D3.2 (A), IC1.4 (SW), L3.2
unnamed: IC1.1 (COMP), R5.1
unnamed: IC1.2 (FDBK), R6.2, R7.1
unnamed: IC2.5 (ENA/DIAGA), R10.2
unnamed: IC2.9 (ENB/DIAGB), R11.2
unnamed: IC2.4 (INA), R12.2
unnamed: IC2.10 (INB), R13.2
unnamed: IC2.7 (PWM), R14.2
unnamed: IC3.5 (ENA/DIAGA), R18.2
unnamed: IC3.9 (ENB/DIAGB), R19.2
unnamed: IC3.4 (INA), R20.2
unnamed: IC3.10 (INB), R21.2
unnamed: IC3.7 (PWM), R22.2
unnamed: IC4.5 (ENA/DIAGA), R28.2
unnamed: IC4.9 (ENB/DIAGB), R30.2
unnamed: IC4.4 (INA), R32.2
unnamed: IC4.10 (INB), R34.2
unnamed: IC4.7 (PWM), R36.2
unnamed: IC5.5 (ENA/DIAGA), R29.2
unnamed: IC5.9 (ENB/DIAGB), R31.2
unnamed: IC5.4 (INA), R33.2
unnamed: IC5.10 (INB), R35.2
unnamed: IC5.7 (PWM), R37.2
unnamed: C3.1, U1.1 (BOOT)
unnamed: R1.2, R2.1, U1.4 (VSENSE)
unnamed: C4.1, U2.1 (BOOT)
unnamed: R3.2, R4.1, U2.4 (VSENSE)
