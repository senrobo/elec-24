# Repository senrobo/elec-24 (continued)

## KiCad design 2024l3/2024l3.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J2: TOF 0; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J3: TOF 1; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J4: TOF 2; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J5: TOF 3; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
R1, R2: 1K; res0603; LCSC C21190; not fitted
SW1, SW2, SW4, SW5: SW_SPDT; SS12D00G3
U1: OpenMV_RT
U2: 4754; bno085
U3: xiao-esp32c3
U7: Teensy 4.0

Connections:
+5V: J1.1, J2.1, J3.1, J4.1, J5.1, R1.1, R2.2, SW1.1 (A), SW2.1 (A), SW4.1 (A), SW5.1 (A)
/CAM PWR: SW2.2 (B), U1.29 (VIN)
/CAM RST: U1.17 (RST); also elsewhere on the board
/CAM RX: U1.10 (P5-RX/SDA/PWM); also elsewhere on the board
/CAM TX: U1.8 (P4-TX/SCL/PWM); also elsewhere on the board
/COM PWR: SW1.2 (B), U2.JP1_1 (VIN)
/COM RST: U2.JP2_4 (~RST); also elsewhere on the board
/COM SCL: U2.JP1_4 (SCL); also elsewhere on the board
/COM SDA: U2.JP1_5 (SDA); also elsewhere on the board
/ESP1 PWR: SW5.2 (B), U3.13 (5V)
/ESP1 RX: U3.7 (RX); also elsewhere on the board
/ESP1 TX: U3.6 (TX); also elsewhere on the board
/L3 RX: J1.3; also elsewhere on the board
/L3 TX: J1.2; also elsewhere on the board
/SCL TOF: J2.3, J3.3, J4.3, J5.3, R2.1, U3.5 (SCL)
/SDA TOF: J2.2, J3.2, J4.2, J5.2, R1.2, U3.4 (SDA)
/TEENSY PWR: SW4.2 (B); also elsewhere on the board
/XSHUT 0: J2.6, U3.0 (A0)
/XSHUT 1: J3.6, U3.9 (MISO)
/XSHUT 2: J4.6, U3.8 (SCK)
/XSHUT 3: J5.6, U3.1 (A1)
GND: J1.4, J2.4, J2.5, J3.4, J3.5, J4.4, J4.5, J5.4, J5.5, U1.15 (GND), U1.31 (GND), U2.JP1_3 (GND), U3.12 (GND); also elsewhere on the board

Notes on the sheet:
BNO085
TOF and ESP32
OpenMV
Connector and MTH

Board: 2 copper layers, 133.0 x 73.5 mm, 31 parts (1 on the bottom side), 22 nets.

Other parts of the board:
U5: Teensy 4.0
kibuzzard-6590F6B4: G***; kibuzzard-6590F6B4
kibuzzard-6590F77B: G***; kibuzzard-6590F77B
kibuzzard-6590F814: G***; kibuzzard-6590F814
kibuzzard-6592C7F1: G***; kibuzzard-6592C7F1

Their connections:
/CAM RST: U5.22 (22/A8); also elsewhere on the board
/CAM RX: U5.20 (20/A6/TX5); also elsewhere on the board
/CAM TX: U5.21 (21/A7/RX5); also elsewhere on the board
/COM RST: U5.13 (13/SCL/LED); also elsewhere on the board
/COM SCL: U5.19 (19/A5/SCL0); also elsewhere on the board
/COM SDA: U5.18 (18/A4/SDA0); also elsewhere on the board
/ESP1 RX: U5.17 (17/A3/TX4/SDA1); also elsewhere on the board
/ESP1 TX: U5.16 (16/A2/RX4/SCL1); also elsewhere on the board
/L3 RX: U5.0 (0/RX1); also elsewhere on the board
/L3 TX: U5.1 (1/TX1); also elsewhere on the board
/TEENSY PWR: U5.VIN; also elsewhere on the board
GND: U5.G1, U5.G3; also elsewhere on the board

## KiCad design Extras/2024l2 (VNH5019)/2024l2 (VNH5019).kicad_pcb

Board: 2 copper layers, 174.0 x 141.0 mm, 108 parts (68 on the bottom side), 71 nets.

Parts:
C1, C2: 10u; cap0603
C3, C4: 10n; cap0603
C5, C6: 220u; EIA-7343-D
C7, C8: 0u1; cap0603
C9, C10, C16, C17: 1uF; cap0603
C11, C12, C19, C20: 680uF; CP_Elec_10x10.5
C13, C18: 0.1u; cap0603
C14: 100u; CP_Elec_8x10.5
C15: 1u; cap0603
C21, C22: 220u; CP_Elec_10x10.5
D1, D2: SS54; SMA (DO-214AC)
D3: SS510; SMA (DO-214AC)
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
IC1: LM2587S-ADJ; TO170P1435X465-6N
J1, J2: Conn_01x02; 14 AWG
J3: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J4: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical
J5: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J6: Conn_01x06; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J7, J8, J9, J10: Conn_01x02; 16 AWG
L1, L2: 15uH; 0630 One Piece Inductor
L3: 68uH; 1040 One Piece Inductor
Q1, Q2, Q3, Q4: AOD482
R1, R2, R39, R40: 10k; res0603
R3, R5: 10K; res0603
R4: 5K9; res0603
R6: 3K24; res0603
R7, R8, R9, R10, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R30, R31, R32, R33, R34, R35: 1k; res0603
R11, R12, R13, R14, R26, R27, R28, R29: 3k3; res0603
R25: 2k94; res0603
R36: 1k5; res0603
R37: 57k; res0603
R38: 1K; res0603
RV1: 10k; Potentiometer_Vishay_TS53YJ_Vertical
SW1: SW_SPST; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW2: SW_SPDT; SS12D00G3
U1, U2: TPS5430DDA; TI_SO-PowerPAD-8
U3: Teensy 4.0
U4, U5, U6, U7: ST_MultiPowerSO-30
kibuzzard-656010D2: G***; kibuzzard-656010D2

Connections:
+3V3: C5.1, C7.1, J5.4, J6.2, L1.2, R3.1
+5V: C6.1, C8.1, J6.1, L2.2, R5.1, R11.1, R12.1, R13.1, R14.1, R26.1, R27.1, R28.1, R29.1, R38.2, SW2.1 (A)
+12V: C1.1, C2.1, C13.1, C14.1, IC1.5 (VIN), J1.2, J2.2, J5.3, L3.1, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), U1.7 (VIN), U2.7 (VIN), U4.12 (VBATT), U5.12 (VBATT), U6.12 (VBATT), U7.12 (VBATT)
+48V: C18.1, C21.1, C22.1, D3.1 (K), J5.2, R37.1
/ESC: J4.1, U3.0 (0/RX1)
/L1 RX: J3.1, U3.21 (21/A7/RX5)
/L1 TX: J3.3, U3.20 (20/A6/TX5)
/L3 RX: J6.3, U3.15 (15/A1/RX3)
/L3 TX: J6.4, U3.14 (14/A0/TX3)
/M1 INA: R15.1, U3.1 (1/TX1)
/M1 INB: R16.2, U3.3
/M1 OUTA: J7.1, U4.1 (OUTA), U4.25 (OUTA), U4.30 (OUTA), U4.33 (OUTA)
/M1 OUTB: J7.2, U4.15 (OUTB), U4.16 (OUTB), U4.21 (OUTB), U4.32 (OUTB)
/M1 PWM: R1.1, R17.2, U3.2
/M2 INA: R30.1, U3.4
/M2 INB: R31.2, U3.6
/M2 OUTA: J8.1, U6.1 (OUTA), U6.25 (OUTA), U6.30 (OUTA), U6.33 (OUTA)
/M2 OUTB: J8.2, U6.15 (OUTB), U6.16 (OUTB), U6.21 (OUTB), U6.32 (OUTB)
/M2 PWM: R32.2, R39.1, U3.5
/M3 INA: R18.1, U3.7 (7/RX2)
/M3 INB: R19.2, U3.9
/M3 OUTA: J9.1, U5.1 (OUTA), U5.25 (OUTA), U5.30 (OUTA), U5.33 (OUTA)
/M3 OUTB: J9.2, U5.15 (OUTB), U5.16 (OUTB), U5.21 (OUTB), U5.32 (OUTB)
/M3 PWM: R2.1, R20.2, U3.8 (8/TX2)
/M4 INA: R33.1, U3.10 (10/CS)
/M4 INB: R34.2, U3.12 (12/MISO)
/M4 OUTA: J10.1, U7.1 (OUTA), U7.25 (OUTA), U7.30 (OUTA), U7.33 (OUTA)
/M4 OUTB: J10.2, U7.15 (OUTB), U7.16 (OUTB), U7.21 (OUTB), U7.32 (OUTB)
/M4 PWM: R35.2, R40.1, U3.11 (11/MOSI)
/M SW: R7.1, R8.2, R9.1, R10.2, R21.1, R22.2, R23.1, R24.2, R38.1, SW1.1 (A)
/TEENSY PWR: SW2.2 (B), U3.VIN
GND: C1.2, C2.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, D1.2 (A), D2.2 (A), IC1.3 (GND), IC1.6 (TAB), J1.1, J2.1, J3.2, J4.3, J5.1, J6.5, J6.6, R1.2, R2.2, R4.2, R6.2, R36.2, R39.2, R40.2, SW1.2 (B), U1.6 (GND), U1.9 (GNDPAD), U2.6 (GND), U2.9 (GNDPAD), U3.G1, U3.G3, U4.18 (GND), U4.19 (GND), U4.20 (GND), U4.26 (GND), U4.27 (GND), U4.28 (GND), U5.18 (GND), U5.19 (GND), U5.20 (GND), U5.26 (GND), U5.27 (GND), U5.28 (GND), U6.18 (GND), U6.19 (GND), U6.20 (GND), U6.26 (GND), U6.27 (GND), U6.28 (GND), U7.18 (GND), U7.19 (GND), U7.20 (GND), U7.26 (GND), U7.27 (GND), U7.28 (GND)
unnamed: C15.1, R25.2
unnamed: C3.2, D1.1 (K), L1.1, U1.8 (PH)
unnamed: C4.2, D2.1 (K), L2.1, U2.8 (PH)
unnamed: D3.2 (A), IC1.4 (SW), L3.2
unnamed: IC1.1 (COMP), R25.1
unnamed: IC1.2 (FDBK), R36.1, RV1.1, RV1.2
unnamed: C9.1, C11.1, Q1.1 (D), U4.3 (VCC), U4.13 (VCC), U4.23 (VCC), U4.31 (VCC)
unnamed: Q1.2 (G), U4.11 (CP)
unnamed: C10.1, C12.1, Q2.1 (D), U5.3 (VCC), U5.13 (VCC), U5.23 (VCC), U5.31 (VCC)
unnamed: Q2.2 (G), U5.11 (CP)
unnamed: C16.1, C19.1, Q3.1 (D), U6.3 (VCC), U6.13 (VCC), U6.23 (VCC), U6.31 (VCC)
unnamed: Q3.2 (G), U6.11 (CP)
unnamed: C17.1, C20.1, Q4.1 (D), U7.3 (VCC), U7.13 (VCC), U7.23 (VCC), U7.31 (VCC)
unnamed: Q4.2 (G), U7.11 (CP)
unnamed: R17.1, U4.7 (PWM)
unnamed: R20.1, U5.7 (PWM)
unnamed: R32.1, U6.7 (PWM)
unnamed: R35.1, U7.7 (PWM)
unnamed: R37.2, RV1.3
unnamed: C3.1, U1.1 (BOOT)
unnamed: R3.2, R4.1, U1.4 (VSENSE)
unnamed: C4.1, U2.1 (BOOT)
unnamed: R5.2, R6.1, U2.4 (VSENSE)
unnamed: R7.2, R13.2, U4.5 (ENA)
unnamed: R8.1, R11.2, U4.9 (ENB)
unnamed: R15.2, U4.4 (INA)
unnamed: R16.1, U4.10 (INB)
unnamed: R9.2, R14.2, U5.5 (ENA)
unnamed: R10.1, R12.2, U5.9 (ENB)
unnamed: R18.2, U5.4 (INA)
unnamed: R19.1, U5.10 (INB)
unnamed: R21.2, R28.2, U6.5 (ENA)
unnamed: R22.1, R26.2, U6.9 (ENB)
unnamed: R30.2, U6.4 (INA)
unnamed: R31.1, U6.10 (INB)
unnamed: R23.2, R29.2, U7.5 (ENA)
unnamed: R24.1, R27.2, U7.9 (ENB)
unnamed: R33.2, U7.4 (INA)
unnamed: R34.1, U7.10 (INB)

## KiCad design LED Plate/LED Plate.kicad_pcb

Parts:
D1, D2, D3, D4: LED; led2835
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Horizontal

Connections:
+3V3: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), J1.2
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.1

Board: 2 copper layers, 9.2 x 12.9 mm, 5 parts (1 on the bottom side), 2 nets.

## KiCad design test (Hardware)/test(Hardware).kicad_pcb

Board: 2 copper layers, 30.2 x 62.6 mm, 26 parts (0 on the bottom side), 26 nets.

Parts:
C1, C2: 1u; cap0603
C3: 470u; CP_Elec_10x10.5
C4: 0u1; cap0603
C5: 47n; cap0603
D1, D2, D3: LED; led0603
J1: Conn_01x02; AMASS_XT60-M
J2: Conn_01x02; AMASS_XT30-F
J3: Conn_01x10; PinSocket_1x10_P2.54mm_Vertical
R1, R3, R9: 330; res0603
R2: 10K; res0603
R4: 0; res0603
R5, R6: 1k; res0603
R7, R8: 390; res0603
SW1, SW2: SW_SPDT; SS12D00G3
U1: SOP65P640X120-25N
kibuzzard-656D5855: G***; kibuzzard-656D5855
kibuzzard-6569A163: G***; kibuzzard-6569A163
kibuzzard-6569A174: G***; kibuzzard-6569A174

Connections:
+3V3: D1.2 (A), J3.2, R2.1
+5V: C2.1, J3.1, SW1.1 (A), SW2.1 (A), U1.1 (DVDD)
+12V: C1.1, C3.1, C4.1, J1.2, U1.13 (VM_1), U1.20 (VM_2)
/DISABLE: D3.2 (A), J3.3, U1.9 (DISABLE)
/EN/IN1: J3.5, U1.7 (EN/IN1)
/IPROPI1: R8.1, U1.10 (IPROPI1)
/IPROPI2: R7.1, U1.12 (IPROPI2)
/MODE: J3.7, U1.3 (MODE)
/OUT1: J2.1, U1.18 (OUT1_1), U1.19 (OUT1_2)
/OUT2: J2.2, U1.14 (OUT2_1), U1.15 (OUT2_2)
/PH/IN2: J3.4, U1.8 (PH/IN2)
/SR: J3.6, U1.4 (SR)
/VCP: C1.2, U1.21 (VCP)
/nFAULT: R1.2, R2.2, U1.2 (NFAULT)
/nITRIP: R6.1, U1.5 (nITRIP)
/nOL: R5.1, U1.6 (nOL)
/nSLEEP: D2.2 (A), J3.8, U1.11 (NSLEEP)
GND: C2.2, C3.2, C4.2, J1.1, J3.9, J3.10, R3.2, R4.1, R7.2, R8.2, R9.2, SW1.3 (C), SW2.3 (C), U1.24 (GND), U1.25 (EP)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R3.1
unnamed: D3.1 (K), R9.1
unnamed: R5.2, SW1.2 (B)
unnamed: R6.2, SW2.2 (B)
unnamed: C5.1, U1.22 (CPH)
unnamed: C5.2, U1.23 (CPL)
unnamed: R4.2, U1.16 (SRC_1), U1.17 (SRC_2)

## Commit log (part)

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2023-09-08 changed to ss12f21 switch on l1
2023-09-09 removed lightweight
2023-09-09 Custom LED Board
2023-09-10 L1- 5050 LED
2023-09-12 L1-Final Version, L1 Single MUX test
2023-09-12 L1 Single Mux - A bit more routing
2023-09-13 L1 - Single MUX Version done
2023-09-13 L1- Almost Production version
2023-09-13 L1 and Single - Flipped Connector
2023-09-14 L1-Production files
2023-09-14 L1- Production files and l3 routing
2023-09-14 fixed some traces
2023-09-14 L1- Fixed edge cuts
2023-09-14 L3- Adjustments
2023-09-14 Changed LED and LDR Footptint
2023-09-14 Revert "Merge branch 'main' of https://github.com/senrobo/2024-Elec"
    This reverts commit 9d58245335508916330972b3431496de00632f84, reversing
    changes made to 7d2caad81fd856a9f7b56a82a4b87fef6df5da35.
2023-09-14 Revert "Changed LED and LDR Footptint"
    This reverts commit 7d2caad81fd856a9f7b56a82a4b87fef6df5da35.
2023-09-14 L1- Added QR code
2023-09-14 L1- Hide Reference labels
2023-09-14 L1-Removed all the silkscreen
2023-09-14 l1- Updated Values of led and ldr
2023-09-15 L1-Final Changes
2023-09-15 L1- Final Changes
2023-09-15 L3- reposition connector
2023-09-16 L3- Updated board
2023-09-16 Production files
2023-09-16 L3- Moved connector position
2023-09-16 small adjustment
2023-09-16 L3-Updated routing
2023-09-16 spring cleaning
2023-09-16 l2 components draft
2023-09-16 l2 step
2023-09-16 l1 step
2023-09-16 L3- rerouted tof
2023-09-16 L2- Update
2023-09-16 L2- Preliminary Changes
2023-09-18 L2-Motor routing
2023-09-18 L2-updates
2023-09-18 drv updated footprint
2023-09-18 L2- Routing
2023-09-18 L2-Routing
2023-09-18 L2- redo buck
2023-09-19 L2- DRV Sch
2023-09-19 drv sch
2023-09-19 L2- Updated Nets
2023-09-19 L2- Changed footprint back
2023-09-19 prelim
2023-09-19 vias
2023-09-19 L2-Motor Driver routing
2023-09-19 L2-Some routing
2023-09-20 l2-Spi routing
2023-09-20 L2- Routed Power (Temporary)
2023-09-20 L2- Battery indicator
2023-09-20 L2-Labbelled components
2023-09-20 L2-Cleaned up Schematic a bit
2023-09-20 L2-Battery Holder, Many things yet to change
2023-09-20 L2- Aligned Schematic
2023-09-21 updated gitignore
2023-09-21 L2- Changed Buck
2023-09-21 L2- L3 to teensy connections
2023-09-21 L2- Stitching Vias
2023-09-21 L2-Fan header
2023-09-21 L2- Reposition battery connectors
2023-09-21 Stitching vias
2023-09-21 L2-BOM
2023-09-21 L2- Stintching via spam
2023-09-21 L2- Swapped Serial pins
2023-09-21 L2- Minor Updates
2023-09-21 Connector movements
2023-09-21 Minor changes
2023-09-21 Edited power connectors
2023-09-21 Production file
2023-09-22 BOM Sadness
2023-09-22 L2 Specify Location
2023-10-09 reformatted
2023-10-10 redid l2 sch
2023-10-10 edited l3
2023-10-10 init routing
2023-10-10 Buck Position
2023-10-10 Motor driver Pours
2023-10-10 L2 Update
2023-10-10 Buck Routing
2023-10-11 SPI On L2
2023-10-11 L2 Routing Draft Complete
2023-10-11 L1 Minor adjust and l2 still need to add stitching vias
2023-10-11 L2 STEP FIle
2023-10-12 Restored L1 Footprint Library
2023-10-12 L3 - SCH
2023-10-13 Vague Placement
2023-10-13 L3 Draft Finished, L2 Need to shift holes more
2023-10-14 L2 Board Update
2023-10-14 Silkscreen
2023-10-15 Production
2023-10-15 L3 change to teensy
2023-11-12 purging
2023-11-12 rough palcement of boost on l2
2023-11-12 5 caps
2023-11-12 revert
2023-11-12 redid step
2023-11-16 Major Rework
2023-11-16 removal of test pcb
2023-11-17 L3 Edit
2023-11-18 L2 Moved Boost
2023-11-19 Boost on L2 and additional resistors
2023-11-19 STEP FIle
2023-11-19 L3 DXF change
2023-11-20 L3 Temp Placement
2023-11-21 L2 Rework
2023-11-22 Rotate Boost
2023-11-22 Boost I think XT hitting
2023-11-22 L3 and L1
2023-11-22 Battery Indicator need parts
2023-11-22 Low Voltage Indicator
2023-11-22 redoing l3
2023-11-22 L3 left with TOF
2023-11-23 Rehauled L1
2023-11-23 Routed 3V3 Line
2023-11-23 Power Routing Done
2023-11-23 L1 Done
2023-11-23 LDR and LED
2023-11-23 Left with Testpoints
2023-11-23 Added Test Points
2023-11-23 Changed POT and Routed L2
2023-11-23 Refreshed Footprint
2023-11-23 reformatted folder
2023-11-23 Shifted Positioning
2023-11-24 Minor Fixes on L1
2023-11-24 L2 Stitching Vias
2023-11-24 L3 Minor edit
2023-11-24 Battery Polarity indicator
2023-11-24 Small edit
2023-11-24 nFualt 12V
2023-11-25 L2 Removed Acute traces
2023-11-25 L3 Schematic
2023-11-26 L3 Partial Routing
2023-11-26 L3 Routing
2023-11-26 L3 Routing Complete
2023-11-26 Purple PCB
2023-11-26 L3 Shift Trace
2023-11-28 Teardrops
2023-11-29 L2 Updates
2023-11-29 L3 DXF Rework
2023-11-29 L3 Reroute
2023-11-29 Test PCB
2023-11-30 L3 DXF Update
2023-12-01 LCSC
2023-12-01 Pin Labels
2023-12-01 Deleted excess
2023-12-01 L3 DXF
2023-12-01 Schematic Formatting
2023-12-04 Test Hardware and L3 DXf
2023-12-04 Test Hardware PCB
2023-12-04 Test PCBS
2023-12-04 DRC Check
    Update test(SPI) board in JLC
2023-12-10 5019 L2
2023-12-11 5019 L2 Routing
2023-12-11 5019 variant step file
2023-12-12 Vnh5019
2023-12-12 Pull down resistors
2023-12-14 Fixed Small-Fet Issue
2023-12-15 L3 Redo
2023-12-16 L2 and L1 Changes
2023-12-16 L3 trace Movement
2023-12-17 Motor Connector
2023-12-22 DRV L2 Rework
2023-12-22 Kicad MDriver Routing
2023-12-22 L2 routing
2023-12-22 Connector Shift
2023-12-22 3D models and STEP files
2023-12-22 Removal of L1 Discharge LED and some stiching vias
2023-12-24 Stitching Vias and Castellated Holes
2023-12-24 Castellated Boards
2023-12-25 L1 Revert
2023-12-28 Sleep Indicator Pin
2023-12-28 Minor Repo Cleanup
2023-12-28 Aesthetic Updates and checks
2023-12-28 Minor Updates
2023-12-29 Minor Trace adjustments
2023-12-29 Adjustment of reistor value from 1k to 10k on L1
2023-12-30 Changed l1 Back
2023-12-30 Added Connector Silkscreen
2023-12-30 L1 Looks Good
2023-12-30 L2 Silkscreen
2023-12-30 Moved Trimpot
2023-12-30 L3 Teardrops
2023-12-31 l2 looks good
2023-12-31 cleaned
2023-12-31 L1 Looks ok
2023-12-31 Have To Do Some Spring Cleaning
2023-12-31 L3 Silk
2023-12-31 LCSC Updates
2023-12-31 OpenMV RT
2023-12-31 Done with footprint left with headers
2023-12-31 Footprint clean need headers
2024-01-01 Move motor switch
2024-01-01 Changed Cap LCSC
2024-01-01 Mod SW Pos
2024-01-01 Boost Caps
2024-01-01 L2 Stuff
2024-01-01 Changed OPENMV FOOTPRINT
2024-01-01 Cam Placement
2024-01-01 L3 Trace Size decrease
2024-01-01 Tmr Check
2024-01-02 Thermal Vias Boost
2024-01-02 Some Change
2024-01-02 Changed Buck Diode
2024-01-02 SPI Pull Up
2024-01-02 L2 Looks ok?
2024-01-02 DNP L3 PULLUP
2024-01-02 Panicking
2024-01-03 CS Pin Pull Up
2024-01-03 Layer 1 Should Be OK
2024-01-04 added switch on l2
2024-01-04 DNP Resistors
2024-01-04 stuff
2024-01-06 .gitignore
2024-01-06 Extra MTH L1
2024-01-06 Added Missing Logo
2024-01-06 Mod Holes, 3D Models
2024-01-06 Cleaned Folder
2024-01-06 L1 looks ok and easter egg
2024-01-06 L1 Edits
2024-01-06 I hate myself switched to 36 Ring
2024-01-07 GND Plane
2024-01-07 l1 mux routing
2024-01-07 Teardrops and stuff
2024-01-07 DXF Update
2024-01-07 L1 Footprint Updates
2024-01-07 3d models
2024-01-07 Fet footprint
2024-01-07 CLeaned L1
2024-01-08 Total 9 Caps
2024-01-08 Updated Cap Footprint
2024-01-08 Minor edits
2024-01-08 L1 Schematic looks ok
2024-01-08 Rotate Logo
2024-01-08 Schematic ok
2024-01-11 Light Gate edit and production files
2024-01-13 L2 5019 dxf update
2024-01-13 L2 5019 changes
2024-01-13 L2 edits
2024-01-13 Rehual Motor Driver
2024-01-13 Rehaul Motor Driver
2024-01-14 Motor Driver FET and Cap Placement
2024-01-14 Revert "Motor Driver FET and Cap Placement"
    This reverts commit 030cdccddb59d109e4e5b1ab37eb582fc4fdd5dd.
2024-01-14 Motor Driver shift
2024-01-14 Sample Driver Placement
2024-01-15 Minor routing l2
2024-01-15 Diode footprint change
2024-01-15 Buck n Boost
2024-01-17 removed boost cap on l2
2024-01-17 L2 Driver Major Edits
2024-01-17 L2 Schematic changes
2024-01-17 Minor trace adjustment
2024-01-17 Jesus wires
2024-01-18 L2 Motor Output
2024-01-18 Motor Switch
2024-01-18 Surface Finish Change
2024-01-18 Smaller Logo
2024-01-19 Polygon
2024-01-19 Zip Tie
2024-01-20 Zip Tie for ESC and samd21
2024-01-20 Zip Ties
2024-01-20 Reroute L1 Switch
2024-01-20 Boost Cap
2024-01-20 10 Caps!!!
2024-01-20 Trace Shift
2024-01-20 Minor Sch Update
2024-01-20 Collision Edits
2024-01-20 14 AWg to Xt60
2024-01-21 Cap Change
2024-01-21 Back to 14 AWG
2024-01-21 !4 AWG
2024-01-22 Kill me already
2024-01-22 Connector shifts
2024-01-23 STEP files
2024-01-23 Readd Trimpot
2024-01-23 Minor Change
2024-02-29 removed trimpot
2024-03-02 L1 refinements
2024-03-03 L3 TF Luna mod and no screen
2024-03-06 Changed OPENMV RT hole sizing
2024-03-06 L1 and L2 Changes
2024-03-06 Changed L3
2024-03-06 L1 Light ring Shrink
2024-03-07 Move switch in
2024-03-07 Current limitng resistor
2024-03-07 Current Limitng resistir
2024-03-09 XH Connector
2024-03-10 Porduction FIles
2024-03-18 I2C Line shift
2024-03-19 FUCK
2024-03-19 Routing L1
2024-03-19 quick push
2024-03-19 Finish Routing
2024-03-19 Schematic
2024-04-17 l1 schematic
2024-07-19 75% L1
2024-11-21 bad number
