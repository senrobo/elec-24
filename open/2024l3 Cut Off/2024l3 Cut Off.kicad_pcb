File: open/2024l3 Cut Off/2024l3 Cut Off.kicad_pcb (KiCad board)
At the start: 2 copper layers, 174 x 119 mm, 22 parts, among them J1 Conn_01x06, J2 TOF 0, J3 TOF 1, J4 TOF 2, J5 TOF 3, U1 OpenMV, U2 4754, U3 xiao-esp32c3, U4 Adafruit Featherwing, U5 Teensy 4.0

Commit message: STEP FIle
Parts:
- moved H7 30.9 mm to (181.5, 65.3)
- moved H8 30.9 mm to (115.5, 65.3)
- moved U4 1.00 mm to (148.5, 64.2)
Other:
- board size 174 x 119 mm -> 174 x 87 mm
Changed lines of the file:
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@@
   )
   (footprint "MountingHole:MountingHole_3.2mm_M3_Pad_Via" (layer "F.Cu")
-    (at 103.052395 37.002422)
+    (at 115.466792 65.278635)
     (descr "Mounting Hole 3.2mm, M3")
     (tags "mounting hole 3.2mm m3")
@@
   )
   (footprint "MountingHole:MountingHole_3.2mm_M3_Pad_Via" (layer "F.Cu")
-    (at 193.939606 37.002422)
+    (at 181.525205 65.278635)
     (descr "Mounting Hole 3.2mm, M3")
     (tags "mounting hole 3.2mm m3")
@@
   )
   (footprint "2024l3:Adafruit Feather OLED" (layer "F.Cu")
-    (at 148.496 63.179 180)
+    (at 148.496 64.179 180)
     (property "Sheetfile" "2024l3 Cut Off.kicad_sch")
     (property "Sheetname" "")
@@
     )
   )
-  (gr_line (start 211.287143 115.004002) (end 211.287143 95.004003)
-    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_arc (start 67.09484 135.709884) (mid 148.496 18.003999) (end 229.897159 135.709884)
-    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_line (start 211.287143 95.004003) (end 224.287143 95.004003)
-    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_line (start 224.287143 115.004002) (end 211.287143 115.004002)
-    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_line (start 68.966131 137.004003) (end 228.025869 137.004003)
-    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_arc (start 68.966131 137.004003) (mid 67.828523 136.648972) (end 67.09484 135.709884)
-    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_line (start 224.287143 95.004003) (end 224.287143 115.004002)
-    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_arc (start 229.897159 135.709884) (mid 229.163462 136.648958) (end 228.025869 137.004003)
-    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_text "JLCJLCJLCJLC" (at 140.771 42.054) (layer "F.SilkS")
+  (gr_arc (start 67.094838 135.709882) (mid 62.556097 91.463932) (end 80.479408 50.75694)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_arc (start 68.966129 137.004) (mid 67.828523 136.648968) (end 67.094838 135.709882)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_arc (start 80.479408 50.75694) (mid 81.175286 50.202043) (end 82.043007 50.004)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_line (start 224.287142 95.003999) (end 224.287142 115.004)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_line (start 214.94899 50.004) (end 82.043007 50.004)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_arc (start 229.897159 135.709882) (mid 229.163461 136.648956) (end 228.025868 137.004)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_line (start 211.287142 115.004) (end 211.287142 95.003999)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_line (start 211.287142 95.003999) (end 224.287142 95.003999)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_line (start 68.966129 137.004) (end 228.025868 137.004)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_arc (start 214.94899 50.004) (mid 215.816711 50.20204) (end 216.512589 50.75694)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_line (start 224.287142 115.004) (end 211.287142 115.004)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_arc (start 216.512589 50.75694) (mid 234.4359 91.463932) (end 229.897159 135.709882)
+    (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
+  (gr_text "JLCJLCJLCJLC" (at 140.771 67.054) (layer "F.SilkS")
     (effects (font (size 1.5 1.5) (thickness 0.3) bold) (justify left bottom))
   )
@@
     )
   )
-  (group "" (id d5c53182-f4eb-4ee6-a37b-190a7e240ec7)
+  (group "" (id 187da8aa-159e-4375-a764-e9f66b501069)
     (members
-      0ec7b0be-fae6-4b1a-86a2-e70fa4a870fb
-      108433e7-5be6-430a-a8fe-c9687ab93f13
-      3fbd9048-8f66-4564-b464-fc04d807d5b8
-      4a403a17-aa3c-45cd-bd99-dfb66b715e04
-      5595356c-226e-4fae-ae46-ec121ea8306f
-      c063c772-a7d5-46ff-9b80-64e274719699
-      c4b7e0c8-40b9-4c58-98a0-e147af8b5097
-      cb11e9ae-ab34-42b0-8c97-c229fd758920
-    )
-  )
+      21106090-f5e7-49d6-bdb2-1c002f9a16e3
+      47df7ce1-4407-45b8-a698-bbba8da43787
+      57bdda2a-994b-4006-855e-76fd6243d497
+      5a2a70b5-4362-440d-96fa-72615f4c3de4
+      63bd1780-7daa-4e55-8e3d-3a7c572145e7
+      6464e2b7-11b8-4145-af13-8eed389b98da
+      7127d337-6364-40a2-a53e-5e8c678f1f10
+      730340cb-0144-4975-b9f4-1821ff8194c4
+      7896ad17-8745-4ab9-b3c3-73ffb36cedbb
+      81acd5bf-bab6-4e4c-883e-61ed4dca0122
+      bc86eca1-215c-442b-b8b0-712fb2bdbb35
+      cef757ee-bf34-4741-b341-c479a45f9a03
+    )
+  )

Commit message: L3 DXF change
Parts:
- added H11: MountingHole_Pad, MountingHole:MountingHole_3.2mm_M3_Pad_Via, F.Cu at (209.5, 127.5)
- added H12: MountingHole_Pad, MountingHole:MountingHole_3.2mm_M3_Pad_Via, F.Cu at (87.5, 82.5)
- moved U5 74.6 mm to (159.3, 76.1), turned to -90 degrees
- moved U3 74.1 mm to (130.0, 75.7), turned to 90 degrees
- moved J5 38.9 mm to (181.0, 130.3)
- moved J3 38.9 mm to (116.0, 79.7)
- moved H3 35.2 mm to (87.5, 127.5)
- moved H9 35.2 mm to (209.5, 82.5)
- moved H2 30.9 mm to (97.6, 118.2)
- moved H5 30.9 mm to (199.4, 118.2)
- moved H6 30.9 mm to (199.4, 91.8)
- moved H1 30.9 mm to (97.6, 91.8)
- moved J2 20.0 mm to (88.2, 98.7)
- moved J4 20.0 mm to (208.8, 111.4)
- moved H4 10.6 mm to (164.5, 127.5)
- moved H10 10.6 mm to (132.5, 82.5)
- moved J1 10.0 mm to (154.7, 50.0)
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Other:
- board size 174 x 87 mm -> 140 x 100 mm

Commit message: L3 Temp Placement
Parts:
- U3: value xiao-esp32c3 -> >VALUE
- moved Ue 5.98 mm to (159.1, 70.1)
- moved U3 5.73 mm to (129.9, 70.0)
- moved U4 5.10 mm to (148.5, 49.1)
- moved J1 5.00 mm to (154.7, 45.0)
- moved H3 2.66 mm to (84.9, 127.5)
- moved H12 2.66 mm to (84.9, 82.5)
- moved H9 2.66 mm to (212.1, 82.5)
- moved H11 2.66 mm to (212.1, 127.5)
- moved H4 2.66 mm to (167.1, 127.5)
- moved H10 2.66 mm to (129.9, 82.5)
- renumbered U5 to Ue
Other:
- board size 140 x 100 mm -> 145 x 102.5 mm

Commit message: L2 Rework
Parts:
- moved U4 52.5 mm to (201.0, 47.8)
- moved H12 8.02 mm to (92.9, 82.5)
- moved H3 8.02 mm to (92.9, 127.5)
- moved H9 8.02 mm to (204.1, 82.5)
- moved H11 8.02 mm to (204.1, 127.5)
Other:
- board size 145 x 102.5 mm -> 130 x 95 mm
Changed lines of the file:
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@@
   )
   (footprint "MountingHole:MountingHole_3.2mm_M3_Pad_Via" (layer "F.Cu")
-    (at 84.85639 127.504)
+    (at 92.874511 127.503998)
     (descr "Mounting Hole 3.2mm, M3")
     (tags "mounting hole 3.2mm m3")
@@
   )
   (footprint "MountingHole:MountingHole_3.2mm_M3_Pad_Via" (layer "F.Cu")
-    (at 84.85639 82.504)
+    (at 92.874511 82.503998)
     (descr "Mounting Hole 3.2mm, M3")
     (tags "mounting hole 3.2mm m3")
@@
   )
   (footprint "MountingHole:MountingHole_3.2mm_M3_Pad_Via" (layer "F.Cu")
-    (at 212.135609 82.504)
+    (at 204.117489 82.503998)
     (descr "Mounting Hole 3.2mm, M3")
     (tags "mounting hole 3.2mm m3")
@@
   )
   (footprint "MountingHole:MountingHole_3.2mm_M3_Pad_Via" (layer "F.Cu")
-    (at 212.135608 127.504001)
+    (at 204.11749 127.503998)
     (descr "Mounting Hole 3.2mm, M3")
     (tags "mounting hole 3.2mm m3")
@@
   )
   (footprint "2024l3:Adafruit Feather OLED" (layer "F.Cu")
-    (at 148.496 49.079 180)
+    (at 200.966 47.789 180)
     (property "Sheetfile" "2024l3 Cut Off.kicad_sch")
     (property "Sheetname" "")
@@
     )
   )
-  (gr_arc (start 81.959267 133.798326) (mid 148.496 32.504) (end 215.032732 133.798326)
+  (gr_arc (start 92.060197 135.003998) (mid 91.006107 134.703669) (end 90.268585 133.892887)
     (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_line (start 200.025206 66.307838) (end 200.025206 86.307837)
+  (gr_line (start 176.525207 84.807835) (end 176.525208 71.807835)
     (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_line (start 187.025206 86.307837) (end 187.025206 66.307837)
+  (gr_line (start 196.525207 71.807837) (end 196.525207 84.807835)
     (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_arc (start 83.794764 135.004) (mid 82.696747 134.67561) (end 81.959267 133.798326)
+  (gr_line (start 196.525207 84.807835) (end 176.525207 84.807835)
     (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_line (start 200.025206 86.307837) (end 187.025206 86.307837)
+  (gr_arc (start 206.723417 133.892887) (mid 205.985897 134.703671) (end 204.931805 135.003998)
     (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_line (start 187.025206 66.307837) (end 200.025206 66.307838)
+  (gr_line (start 92.060197 135.003998) (end 204.931805 135.003998)
     (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_arc (start 215.032732 133.798326) (mid 214.295267 134.675625) (end 213.197234 135.004001)
+  (gr_arc (start 90.268585 133.892887) (mid 148.496 40.004003) (end 206.723417 133.892887)
     (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
-  (gr_line (start 83.794764 135.004) (end 213.197234 135.004001)
+  (gr_line (start 176.525208 71.807835) (end 196.525207 71.807837)
     (stroke (width 0.2) (type solid)) (layer "Edge.Cuts"))
   (gr_text "JLCJLCJLCJLC" (at 140.771 52.054) (layer "F.SilkS")
@@
     )
   )
-  (group "" (id a9ceca77-9d0c-4484-bbd6-67c0697fbb8f)
+  (group "" (id 2f615264-3b2d-4de4-9c8a-13aa1499d07d)
     (members
-      0c8db981-5e0f-4adf-ae9d-cf03069fcef9
-      3f1ace13-9aae-4510-98f7-9f0a77aae3a9
-      4e7adc68-eeab-43c4-8cb2-27f40c763ac4
-      a93ab436-5f7a-4b12-a3b2-c2bcf9e58466
-      e6316621-fd45-4b37-9c75-58c01dae547a
-      f1681a63-f488-4532-8e1c-e349776d0e1a
-      f29fcabd-69e5-4ebc-a4af-b616d8c2b4f3
-      f406ef61-48c5-4dd7-9766-605e349f1301
-    )
-  )
+      10c34566-5998-46c4-ab72-9566cae8012f
+      227c8610-e846-428c-a9dd-2ed2404093d8
+      2b99fa6d-33e3-4eac-99bf-6c4465eb1167
+      37221c47-1c71-4c02-b7d2-052ff18d907c
+      8e68044b-9d12-4167-8a14-2b39a1a16d04
+      9cbb6dc5-14f8-4b03-9705-eb9d60398a2a
+      a534233a-c49f-42db-91d4-7882bfb0096d
+      dcef2ecc-9f6a-4767-b10a-4d5d58bab9a3
+    )
+  )
