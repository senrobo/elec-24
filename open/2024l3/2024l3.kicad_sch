File: open/2024l3/2024l3.kicad_sch (KiCad schematic)
At the start: 26 parts, among them J1 Conn_01x10, J2 TOF 0, J3 TOF 1, J4 TOF 2, J5 TOF 3, U1 OpenMV, U2 4754, U3 xiao-esp32c3, U4 Adafruit Featherwing, U5 Seeed Studio XIAO SAMD21

Commit message: L1- Fixed edge cuts
Connections:
- net ESP RX: now also J1.7 (Pin_7); no longer J1.6 (Pin_6)
- net ESP TX: now also J1.6 (Pin_6); no longer J1.7 (Pin_7)
- net XSHUT 0: now also U3.0 (A0); no longer U3.2 (A2)
- net XSHUT 1: now also U3.1 (A1); no longer U3.3 (A3)
- net XSHUT 2: now also U3.2 (A2); no longer U3.0 (A0)
- net XSHUT 3: now also U3.3 (A3); no longer U3.1 (A1)
Changed lines of the file:
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@@
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 143.1158 38.7398) (xy 153.4085 38.7398))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 64.376 49.2873) (xy 68.821 49.2873))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 14.8002 92.1565) (xy 23.6902 92.1565))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 68.821 23.2523) (xy 68.821 26.4273))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 138.0702 43.8198) (xy 153.4085 43.8198))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 176.4279 125.297) (xy 168.8079 125.297))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 143.1158 33.6598) (xy 153.4085 33.6598))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 228.1656 25.8226) (xy 219.2226 25.8226))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 201.088 25.066) (xy 192.145 25.066))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 64.376 28.9673) (xy 73.266 28.9673))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 168.8079 110.024) (xy 160.7955 110.024))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 88.6629 113.8305) (xy 98.9556 113.8305))
+    (stroke (width 0) (type default))
+  )
+  (polyline (pts (xy 135.8088 12.0264) (xy 135.8142 12.0264))
+    (stroke (width 0) (type default))
+  )
+  (polyline (pts (xy 135.8088 69.5957) (xy 135.8088 12.0264))
+    (stroke (width 0) (type dash))
+  )
+  (wire (pts (xy 140.8656 113.8305) (xy 151.1583 113.8305))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 88.6629 106.2105) (xy 98.9556 106.2105))
+    (stroke (width 0) (type default))
+  )
+  (polyline (pts (xy 81.2697 69.5626) (xy 81.2697 69.5957))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 192.145 30.146) (xy 202.4377 30.146))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 88.0546 50.1874) (xy 96.9446 50.1874))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 64.376 31.5073) (xy 73.266 31.5073))
+    (stroke (width 0) (type default))
+  )
+  (polyline (pts (xy 236.5875 69.6052) (xy 236.6852 141.2664))
+    (stroke (width 0) (type dash))
+  )
+  (wire (pts (xy 160.7955 110.024) (xy 160.7955 114.4773))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 88.6629 102.4005) (xy 98.9556 102.4005))
+    (stroke (width 0) (type default))
+  )
+  (polyline (pts (xy 236.5833 12.022) (xy 236.5833 69.5929))
+    (stroke (width 0) (type dash))
+  )
+  (wire (pts (xy 64.376 36.5873) (xy 73.266 36.5873))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 219.2226 30.9026) (xy 229.5153 30.9026))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 227.8962 47.44) (xy 218.9532 47.44))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 143.1158 31.1198) (xy 153.4085 31.1198))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 64.376 49.2873) (xy 68.821 49.2873))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 14.8002 92.1565) (xy 23.6902 92.1565))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 68.821 23.2523) (xy 68.821 26.4273))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 138.0702 43.8198) (xy 153.4085 43.8198))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 176.4279 125.297) (xy 168.8079 125.297))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 143.1158 33.6598) (xy 153.4085 33.6598))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 228.1656 25.8226) (xy 219.2226 25.8226))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 201.088 25.066) (xy 192.145 25.066))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 64.376 28.9673) (xy 73.266 28.9673))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 168.8079 110.024) (xy 160.7955 110.024))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 88.6629 113.8305) (xy 98.9556 113.8305))
-    (stroke (width 0) (type default))
-  )
-  (polyline (pts (xy 135.8088 12.0264) (xy 135.8142 12.0264))
-    (stroke (width 0) (type default))
-  )
-  (polyline (pts (xy 135.8088 69.5957) (xy 135.8088 12.0264))
-    (stroke (width 0) (type dash))
-  )
-  (wire (pts (xy 140.8656 113.8305) (xy 151.1583 113.8305))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 88.6629 106.2105) (xy 98.9556 106.2105))
-    (stroke (width 0) (type default))
-  )
-  (polyline (pts (xy 81.2697 69.5626) (xy 81.2697 69.5957))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 192.145 30.146) (xy 202.4377 30.146))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 88.0546 50.1874) (xy 96.9446 50.1874))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 64.376 31.5073) (xy 73.266 31.5073))
-    (stroke (width 0) (type default))
-  )
-  (polyline (pts (xy 236.5875 69.6052) (xy 236.6852 141.2664))
-    (stroke (width 0) (type dash))
-  )
-  (wire (pts (xy 160.7955 110.024) (xy 160.7955 114.4773))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 143.1158 38.7398) (xy 153.4085 38.7398))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 88.6629 102.4005) (xy 98.9556 102.4005))
-    (stroke (width 0) (type default))
-  )
-  (polyline (pts (xy 236.5833 12.022) (xy 236.5833 69.5929))
-    (stroke (width 0) (type dash))
-  )
-  (wire (pts (xy 219.2226 30.9026) (xy 229.5153 30.9026))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 227.8962 47.44) (xy 218.9532 47.44))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 201.2389 46.9115) (xy 192.2959 46.9115))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type dash))
   )
+  (wire (pts (xy 143.1158 36.1998) (xy 153.4085 36.1998))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 95.6574 98.5905) (xy 98.9556 98.5905))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 143.1158 36.1998) (xy 153.4085 36.1998))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 14.8002 94.6965) (xy 23.6902 94.6965))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 64.376 36.5873) (xy 73.266 36.5873))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 64.376 41.6673) (xy 73.266 41.6673))
     (stroke (width 0) (type default))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "ESP RX" (at 65.646 36.5873 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (label "SCL TOF" (at 194.8927 49.4515 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "XSHUT 2" (at 144.8583 31.1198 0) (fields_autoplaced)
+  (label "ESP RX" (at 65.646 34.0473 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "XSHUT 1" (at 144.8167 38.7398 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (label "COM SDA" (at 88.4224 52.7274 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "XSHUT 0" (at 144.7679 36.1998 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (label "OLED SCL" (at 89.353 110.0205 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "ESP TX" (at 65.646 34.0473 0) (fields_autoplaced)
+  (label "XSHUT 0" (at 144.7679 31.1198 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
+  (label "ESP TX" (at 65.646 36.5873 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "ESP TX" (at 145.7885 46.3598 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
+  (label "XSHUT 3" (at 144.857 38.7398 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "C" (at 184.956 97.3993 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
+  (label "XSHUT 1" (at 144.8167 33.6598 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "COM SDA" (at 65.646 41.6673 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "XSHUT 3" (at 144.857 33.6598 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (label "COM RST" (at 88.6323 34.9474 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
+  (label "XSHUT 2" (at 144.8583 36.1998 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )

Commit message: L3- Adjustments
Connections:
- net +3V0: no longer C2.2, R3.1
- net A: now also U5.1 (PA02_A0_D0); no longer U5.3 (PA10_A2_D2)
- net C: now also U5.3 (PA10_A2_D2); no longer U5.1 (PA02_A0_D0)
- new net: C2.2, R3.1
Changed lines of the file:
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@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 95.6531 90.9705) (xy 98.9556 90.9705))
+  (wire (pts (xy 95.6531 98.5905) (xy 98.9556 98.5905))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 197.91 110.024) (xy 197.91 117.644))
-    (stroke (width 0) (type default))
-  )
   (polyline (pts (xy 12.0423 69.565) (xy 81.274 69.565))
     (stroke (width 0) (type dash))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 95.6574 98.5905) (xy 98.9556 98.5905))
+  (wire (pts (xy 95.6574 90.9705) (xy 98.9556 90.9705))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "A" (at 96.8823 98.5905 0) (fields_autoplaced)
+  (label "A" (at 96.8823 90.9705 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "C" (at 96.8073 90.9705 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
+  (label "C" (at 96.8073 98.5905 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )

Commit message: L3- reposition connector
Parts:
- removed R3: 2r, 2024l3:res0603, symbol Device:R
- removed U6: ~, Package_TO_SOT_SMD:SOT-23-5, symbol TPS77030:TPS77030
- added U6: C5199435, Package_TO_SOT_SMD:SOT-223, symbol Device (Modified):AMS117
- C1: value 1uF -> 10uF; footprint 2024l3:cap0603 -> Capacitor_Tantalum_SMD:CP_EIA-3528-15_AVX-H
- C2: value 4.7uF -> 10uF; footprint 2024l3:cap0603 -> Capacitor_Tantalum_SMD:CP_EIA-3528-15_AVX-H
- J1: footprint Connector_JST:JST_XH_S10B-XH-A_1x10_P2.50mm_Horizontal -> Connector_JST:JST_XH_B10B-XH-A_1x10_P2.50mm_Vertical
Connections:
- net +3V0: now also U6.2 (VOUT)
- net +5V: now also U6.3 (VIN)
- net GND: now also C2.2, U6.1 (GND), U6.4 (GND)
- net OLED RX: now also J1.3 (Pin_3); no longer J1.2 (Pin_2)
- net OLED TX: now also J1.2 (Pin_2); no longer J1.3 (Pin_3)
Other:
- moved on the sheet: C1, C2

Commit message: L3- Updated board
Parts:
- removed C1, C2: 10uF, Capacitor_Tantalum_SMD:CP_EIA-3528-15_AVX-H, symbol Device:C
- added C1, C2: 10uF, Capacitor_Tantalum_SMD:CP_EIA-7343-31_Kemet-D, symbol Device:C_Polarized
- added H11: MountingHole, 2024l1:SEN Logo Mini, symbol Mechanical:MountingHole
Connections:
- net +5V: now also C1.1
- net GND: now also C1.2, C2.2; no longer U6.4 (GND)
- net +3V0 renamed +3V3
- net +3V3: now also U6.4 (VOUT), C2.1
