File: open/2024l3/2024l3.kicad_sch (KiCad schematic)
At the start: 32 parts, among them J1 Conn_01x08, J1 PGMR, J2 TOF 0, J3 TOF 1, J4 TOF 2, J5 TOF 3, SW1 STM RST, U1 OpenMV, U1 STM32F103CBTx, U2 4754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

Commit message: L3- Changed OLED microcontroller
Parts:
- removed C1, C2, C3, C4: 0.1uF, 2024l2:cap0603, symbol vincent:C
- removed C5: 100n, 2024l2:cap0603, symbol Device:C
- removed C6, C7: 22p, 2024l2:cap0603, symbol Device:C
- removed D1: LED, 2024l2:led0603, symbol Device:LED
- removed J1: PGMR, Connector_JST:JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical, symbol Connector_Generic:Conn_01x04
- removed R1: 10K, 2024l2:res0603, symbol vincent:R
- removed SW1: STM RST, 2024l2:SW_PUSH_SPST, symbol Switch:SW_Push
- removed U1: STM32F103CBTx, Package_QFP:LQFP-48_7x7mm_P0.5mm, symbol vincent:STM32F103CBTx
- removed Y1: 8Mhz, 2024l1:Crystal, symbol vincent:Crystal
- added U5: Seeed Studio XIAO SAMD21, 2024l1:Seeeduino XIAO SAMD 21 TFT, symbol Seeed_Studio_XIAO_Series:Seeed Studio XIAO SAMD21
Connections:
- net +5V: now also U5.14 (5V), U5.15 (5V)
- net A: now also U5.1 (PA02_A0_D0)
- net B: now also U5.2 (PA4_A1_D1)
- net C: now also U5.3 (PA10_A2_D2)
- net GND: now also U5.13 (GND), U5.16 (GND), U5.20 (GND)
- net OLED SCL: now also U5.6 (PA9_A5_D5_SCL)
- net OLED SDA: now also U5.5 (PA8_A4_D4_SDA)
- net OLED RST: now reaches U4.1 (Reset)
- net OLED RST: now also U5.4 (PA11_A3_D3)
- new net OLED RX: U5.8 (PB09_A7_D7_RX)
- new net OLED TX: U5.7 (PB08_A6_D6_TX)
- no-connect marks 22 -> 4

Commit message: L3- Basic Routing
Parts:
- removed J1: Conn_01x08, Connector_JST:JST_XH_S8B-XH-A_1x08_P2.50mm_Horizontal, symbol Connector_Generic:Conn_01x08
- added H11: Camera Lense, 2024l3:Camera Lense, symbol Mechanical:MountingHole
- added J1: Conn_01x10, Connector_JST:JST_XH_S10B-XH-A_1x10_P2.50mm_Horizontal, symbol Connector_Generic:Conn_01x10
- added R1, R2: 1K, 2024l3:res0603, symbol Device:R
- U1: footprint 2024l3:openmv -> 2024l3:Open MV Module
Connections:
- net +5V: now also J1.10 (Pin_10), R1.1, R2.2
- net A: now also U5.3 (PA10_A2_D2); no longer U5.1 (PA02_A0_D0)
- net C: now also U5.1 (PA02_A0_D0); no longer U5.3 (PA10_A2_D2)
- net CAM RX: now also J1.8 (Pin_8)
- net CAM TX: now also J1.9 (Pin_9)
- net COM RST: now also U5.9 (PA7_A8_D8_SCK)
- net COM SCL: now also J1.4 (Pin_4)
- net COM SDA: now also J1.5 (Pin_5)
- net ESP RX: now also J1.6 (Pin_6)
- net ESP TX: now also J1.7 (Pin_7)
- net GND: now also J1.1 (Pin_1)
- net OLED RX: now also J1.2 (Pin_2)
- net OLED TX: now also J1.3 (Pin_3)
- net SCL TOF: now also R2.1
- net SDA TOF: now also R1.2
- net +3V3 renamed +3V0
Other:
- moved on the sheet: U3, U4, U5

Commit message: L1- Production files and l3 routing
Parts:
- removed H11: Camera Lense, 2024l3:Camera Lense, symbol Mechanical:MountingHole
- added C1: 1uF, 2024l3:cap0603, symbol Device:C
- added C2: 4.7uF, 2024l3:cap0603, symbol Device:C
- added R3: 2r, 2024l3:res0603, symbol Device:R
- added U6: ~, Package_TO_SOT_SMD:SOT-23-5, symbol TPS77030:TPS77030
- J2, J4: footprint Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical -> Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Horizontal
- R1, R2: LCSC (none) -> C21190
- U1: footprint 2024l3:Open MV Module -> 2024l3:openmv
Connections:
- net +3V0: now also C2.1, C2.2, R3.1, U6.5 (OUT)
- net +5V: now also C1.1, U6.1 (IN)
- net COM SCL: now also J1.5 (Pin_5); no longer J1.4 (Pin_4)
- net COM SDA: now also J1.4 (Pin_4); no longer J1.5 (Pin_5)
- net GND: now also C1.2, R3.2, U6.2 (GND), U6.3 (EN)
- net XSHUT 0: now also U3.2 (A2); no longer U3.0 (A0)
- net XSHUT 1: now also U3.3 (A3); no longer U3.1 (A1)
- net XSHUT 2: now also U3.0 (A0); no longer U3.2 (A2)
- net XSHUT 3: now also U3.1 (A1); no longer U3.3 (A3)
